# Keil uVision project Erebus_Sensor_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3246PVI-147 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: Erebus_Sensor_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h Vbus.c Vbus.h Vbus_aliases.h USBUART.c USBUART.h USBUART_audio.c USBUART_audio.h USBUART_boot.c USBUART_cdc.c USBUART_cdc.h USBUART_cls.c USBUART_descr.c USBUART_drv.c USBUART_episr.c USBUART_hid.c USBUART_hid.h USBUART_pm.c USBUART_std.c USBUART_vnd.c USBUART_cdc.inf USBUART_midi.c USBUART_midi.h USBUART_pvt.h USBUART_Dm.c USBUART_Dm.h USBUART_Dm_aliases.h USBUART_Dp.c USBUART_Dp.h USBUART_Dp_aliases.h Vbus_IRQ.c Vbus_IRQ.h Em_EEPROM.c Em_EEPROM.h ADC.c ADC.h ADC_PM.c ADC_INT.c ADC_AMux.c ADC_AMux.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_IRQ.c ADC_IRQ.h ADC_theACLK.c ADC_theACLK.h StartCollection_B.c StartCollection_B.h StartCollection_B_aliases.h StopCollection_B.c StopCollection_B.h StopCollection_B_aliases.h StopCollection_IRQ.c StopCollection_IRQ.h StartCollection_IRQ.c StartCollection_IRQ.h RTC.c RTC.h RTC_INT.c Sensor_In.c Sensor_In.h Sensor_In_aliases.h RGB_LED.c RGB_LED.h RGB_LED_aliases.h LED_PWM.c LED_PWM.h LED_PWM_PM.c PWM0_CTRL.c PWM0_CTRL.h PWM1_CTRL.c PWM1_CTRL.h SOLID_LED_CTRL.c SOLID_LED_CTRL.h Batt_Monitor.c Batt_Monitor.h Batt_Monitor_aliases.h ADC_MUX.c ADC_MUX.h Re_EEPROM.c Re_EEPROM.h
target Release (MCS-51)
  device: CY8C3246PVI-147 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: Erebus_Sensor_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
