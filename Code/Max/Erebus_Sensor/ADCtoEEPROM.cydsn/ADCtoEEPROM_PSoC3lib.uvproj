# Keil uVision project ADCtoEEPROM_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: ADCtoEEPROM_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h Em_EEPROM_1.c Em_EEPROM_1.h LCD_Char_1.c LCD_Char_1.h LCD_Char_1_PM.c Pin_1.c Pin_1.h Pin_1_aliases.h ADC_DelSig_2.c ADC_DelSig_2.h ADC_DelSig_2_PM.c ADC_DelSig_2_INT.c isr_1.c isr_1.h Pin_2.c Pin_2.h Pin_2_aliases.h LCD_Char_1_LCDPort.c LCD_Char_1_LCDPort.h LCD_Char_1_LCDPort_aliases.h ADC_DelSig_2_AMux.c ADC_DelSig_2_AMux.h ADC_DelSig_2_Ext_CP_Clk.c ADC_DelSig_2_Ext_CP_Clk.h ADC_DelSig_2_IRQ.c ADC_DelSig_2_IRQ.h ADC_DelSig_2_theACLK.c ADC_DelSig_2_theACLK.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: ADCtoEEPROM_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
