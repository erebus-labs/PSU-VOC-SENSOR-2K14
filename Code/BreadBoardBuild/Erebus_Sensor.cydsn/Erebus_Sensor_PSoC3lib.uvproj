# Keil uVision project Erebus_Sensor_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3246PVI-147 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: Erebus_Sensor_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h Vbus.c Vbus.h Vbus_aliases.h USBUART.c USBUART.h USBUART_audio.c USBUART_audio.h USBUART_boot.c USBUART_cdc.c USBUART_cdc.h USBUART_cls.c USBUART_descr.c USBUART_drv.c USBUART_episr.c USBUART_hid.c USBUART_hid.h USBUART_pm.c USBUART_std.c USBUART_vnd.c USBUART_cdc.inf USBUART_midi.c USBUART_midi.h USBUART_pvt.h USBUART_Dm.c USBUART_Dm.h USBUART_Dm_aliases.h USBUART_Dp.c USBUART_Dp.h USBUART_Dp_aliases.h EEPROM_R.c EEPROM_R.h USB_LED.c USB_LED.h USB_LED_aliases.h Vbus_IRQ.c Vbus_IRQ.h Em_EEPROM.c Em_EEPROM.h ADC.c ADC.h ADC_PM.c ADC_INT.c TakeSample_IRQ.c TakeSample_IRQ.h ADC_AMux.c ADC_AMux.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_IRQ.c ADC_IRQ.h ADC_theACLK.c ADC_theACLK.h EEPROM_LED.c EEPROM_LED.h EEPROM_LED_aliases.h StartCollection_B.c StartCollection_B.h StartCollection_B_aliases.h StopCollection_B.c StopCollection_B.h StopCollection_B_aliases.h Hibernate_B.c Hibernate_B.h Hibernate_B_aliases.h Hibernate_IRQ.c Hibernate_IRQ.h StopCollection_IRQ.c StopCollection_IRQ.h StartCollection_IRQ.c StartCollection_IRQ.h RTC.c RTC.h RTC_INT.c TakeSample_B.c TakeSample_B.h TakeSample_B_aliases.h Sensor_In.c Sensor_In.h Sensor_In_aliases.h Blink_Clock.c Blink_Clock.h EEPROM_Blink_TI.c EEPROM_Blink_TI.h EEPROM_Blink_TI_PM.c USB_Blink_TI.c USB_Blink_TI.h USB_Blink_TI_PM.c FLASH_LED.c FLASH_LED.h FLASH_LED_aliases.h Flash_Blink_TI.c Flash_Blink_TI.h Flash_Blink_TI_PM.c
target Release (MCS-51)
  device: CY8C3246PVI-147 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: Erebus_Sensor_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
