# Keil uVision project Erebus_Sensor_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Erebus_Sensor_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h LED.c LED.h LED_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h timer_clock.c timer_clock.h Vbus.c Vbus.h Vbus_aliases.h USBUART.c USBUART.h USBUART_audio.c USBUART_audio.h USBUART_boot.c USBUART_cdc.c USBUART_cdc.h USBUART_cls.c USBUART_descr.c USBUART_drv.c USBUART_episr.c USBUART_hid.c USBUART_hid.h USBUART_pm.c USBUART_std.c USBUART_vnd.c USBUART_cdc.inf USBUART_midi.c USBUART_midi.h USBUART_pvt.h Blink_Timer.c Blink_Timer.h Blink_Timer_PM.c USBUART_Dm.c USBUART_Dm.h USBUART_Dm_aliases.h USBUART_Dp.c USBUART_Dp.h USBUART_Dp_aliases.h EEPROM_R.c EEPROM_R.h debounce_clock.c debounce_clock.h USB_LED.c USB_LED.h USB_LED_aliases.h EEPROM_LED.c EEPROM_LED.h EEPROM_LED_aliases.h Vbus_IRQ.c Vbus_IRQ.h Em_EEPROM.c Em_EEPROM.h Potentiometer.c Potentiometer.h Potentiometer_aliases.h ADC.c ADC.h ADC_PM.c ADC_INT.c TakeSample_IRQ.c TakeSample_IRQ.h SW_3.c SW_3.h SW_3_aliases.h ADC_AMux.c ADC_AMux.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_IRQ.c ADC_IRQ.h ADC_theACLK.c ADC_theACLK.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Erebus_Sensor_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
